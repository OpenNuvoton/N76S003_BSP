# Keil uVision project ADC_Bandgap_VDD.uvproj, settings and files
target ADC_Bandgap_VDD (MCS-51)
  device: N76S003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x3FF) CLOCK(16000000)
  output: ADC_Bandgap_VDD +hex
  AfterMake: $KC51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c common.c delay.c adc.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
